options:
  parameters:
    generate_options: qt_gui
    id: Ejercicio_11B
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\usuario\Desktop\ejer\tono.wav
    repeat: 'False'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '3'
    taps: '1'
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '2'
    taps: '1'
    type: fcc
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '32000'
    style2: '0'
    type: complex
  states: {}

connections:
- [blocks_throttle2_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
